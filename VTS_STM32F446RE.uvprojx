# Keil uVision project VTS_STM32F446RE.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VTS_STM32F446RE
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Users\Ali\Desktop\Development\VTS_STM32F446RE\src\main.c
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    C:/Users/Ali/Desktop/Development/VTS_STM32F446RE/src/: main.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
